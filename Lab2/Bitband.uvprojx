# Keil uVision project Bitband.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Bitband
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./RTE/bitbanding/: bitband.c bitband.h
    ./RTE/cond_exe/: cond_ex.c
    ./RTE/Barrel_shifting/: Barrel_shifting.c
    ./: lab2_debug.c lab2_demo.c GLCD_SPI_LPC1700.c
software components: CMSIS:CORE 5.6.0, Board Support:LED 1.0.0, Compiler:Event Recorder 1.5.1, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0

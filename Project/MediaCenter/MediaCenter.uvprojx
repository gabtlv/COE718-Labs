# Keil uVision project MediaCenter.uvprojx, settings and files
target MediaCenter (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MediaCenter +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\DMA.sct
  group App
    ./: main.c input.c menu.c gallery.c mp3.c mines.c flappy.c sound.c app.h input.h config.h sound.h
  group Drivers
    ./: GLCD_SPI_LPC1700.c LED.c
  group USB Audio
    ./: usbuser.c usbcore.c usbdesc.c usbhw.c adcuser.c
  group Resources
    ./: photo1.c photo2.c photo3.c photo_lite.c
  group Startup Files
    ./: system_LPC17xx.c core_cm3.c startup_LPC17xx.s

# Keil uVision project MediaCenter.uvproj, settings and files
target Flash (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: MediaCenter +hex
  c flags: Optim=1
  c include: .\common\inc;.\common\src
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x4000
  scatter file: .\DMA.sct
  group App
    ./: main.c input.c menu.c gallery.c mp3.c mines.c flappy.c sound.c app.h input.h config.h sound.h
  group Drivers
    ./: GLCD_SPI_LPC1700.c LED.c
  group USB Audio
    ./: usbuser.c usbcore.c usbdesc.c usbhw.c adcuser.c
  group Resources
    ./: photo1.c photo2.c photo3.c photo_lite.c
  group Startup Files
    ./: system_LPC17xx.c core_cm3.c startup_LPC17xx.s
